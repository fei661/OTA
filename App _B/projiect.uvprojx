# Keil uVision project projiect.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projiect +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ".\Objects\app_b.bin" ".\Objects\projiect.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8040000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c led.h led.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1
